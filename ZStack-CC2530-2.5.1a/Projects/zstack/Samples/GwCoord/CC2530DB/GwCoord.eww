<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GwCoord.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>GwCoord</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>GwCoord</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>GwCoord</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>GwCoord</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


