<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ZbNode.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ZbNode</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>ZbNode</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>ZbNode</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>ZbNode</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


